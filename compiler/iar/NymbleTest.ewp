# IAR project NymbleTest.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74
  ICCARM.CCIncludePath2: ..\..\..; ..\..\sdk\components\ble\ble_db_discovery; ..\..\sdk\components\ble\ble_services\ble_nus_c; ..\..\sdk\components\ble\common; ..\..\sdk\components\ble\nrf_ble_gatt; ..\..\sdk\components\ble\nrf_ble_gq; ..\..\sdk\components\ble\nrf_ble_scan; ..\..\sdk\components\libraries\atomic; ..\..\sdk\components\libraries\atomic_fifo; ..\..\sdk\components\libraries\atomic_flags; ..\..\sdk\components\libraries\balloc; ..\..\sdk\components\libraries\button; ..\..\sdk\components\libraries\delay; ..\..\sdk\components\libraries\experimental_section_vars; ..\..\sdk\components\libraries\fifo; ..\..\sdk\components\libraries\log; ..\..\sdk\components\libraries\log\src; ..\..\sdk\components\libraries\memobj; ..\..\sdk\components\libraries\mutex; ..\..\sdk\components\libraries\pwr_mgmt; ..\..\sdk\components\libraries\queue; ..\..\sdk\components\libraries\ringbuf; ..\..\sdk\components\libraries\sortlist; ..\..\sdk\components\libraries\strerror; ..\..\sdk\components\libraries\timer; ..\..\sdk\components\libraries\uart; ..\..\sdk\components\libraries\util; ..\..\sdk\components\softdevice\common; ..\..\sdk\components\softdevice\s132\headers; ..\..\sdk\components\softdevice\s132\headers\nrf52; ..\..\sdk\components\toolchain\cmsis\include; ..\..\sdk\external\fprintf; ..\..\sdk\external\segger_rtt; ..\..\sdk\integration\nrfx; ..\..\sdk\integration\nrfx\legacy; ..\..\sdk\modules\nrfx; ..\..\sdk\modules\nrfx\drivers\include; ..\..\sdk\modules\nrfx\hal; ..\..\sdk\modules\nrfx\mdk; ..\..\config; ..\..\application\eeprom; ..\..\application\uart; ..\..\application\power; ..\..\application\crc8; ..\..\application\msg; ..\..\application\statemachine
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=7; S132; SOFTDEVICE_PRESENT
  OBJCOPY.OOCOutputFile: NymbleTest.hex
  ILINK.IlinkOutputFile: NymbleTest.out
  ILINK.IlinkIcfFile: NymbleTest.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application
    ../../application/: main.c
  group application/crc8
    ../../application/crc8/: Nymble_Crc8.c Nymble_Crc8.h
  group application/eeprom
    ../../application/eeprom/: Nymble_eeprom.c Nymble_Eeprom.h
  group application/msg
    ../../application/msg/: Nymble_Msg.c Nymble_Msg.h
  group application/power
    ../../application/power/: Nymble_Power.c Nymble_Power.h
  group application/statemachine
    ../../application/statemachine/: Nymble_Sm.c Nymble_Sm.h
  group application/uart
    ../../application/uart/: Nymble_Uart.c Nymble_Uart.h
  group config
    ../../config/: application_config.h sdk_config.h
    ./: NymbleTest.icf
  group None
    ../../sdk/modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_Drivers
    ../../sdk/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../sdk/modules/nrfx/soc/: nrfx_atomic.c
    ../../sdk/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_uart.c nrfx_uarte.c
    ../../sdk/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../sdk/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c
    ../../sdk/components/libraries/fifo/: app_fifo.c
    ../../sdk/components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../sdk/components/libraries/uart/: app_uart_fifo.c
    ../../sdk/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../sdk/components/libraries/atomic/: nrf_atomic.c
    ../../sdk/components/libraries/balloc/: nrf_balloc.c
    ../../sdk/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../sdk/components/libraries/memobj/: nrf_memobj.c
    ../../sdk/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../sdk/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../sdk/components/libraries/sortlist/: nrf_sortlist.c
  group nRF_Log
    ../../sdk/components/libraries/log/src/: nrf_log_frontend.c
